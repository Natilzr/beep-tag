# IAR project wlible_b.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52810_xxAA NordicSemi nRF52810_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; DEVELOP_IN_NRF52832; FLOAT_ABI_SOFT; NRF52810_XXAA; NRF52_PAN_74; NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3; NRF_SD_BLE_API_VERSION=7; S112; SOFTDEVICE_PRESENT; WLI; DEBUG; XXNRF52_10; XXV1; ADC_W
  ICCARM.IExtraOptions: --diag_suppress Pe111
  ICCARM.CCIncludePath2: components\ble\ble_advertising; config; components; components\ble\ble_advertising; components\ble\ble_dtm; components\ble\ble_racp; components\ble\ble_services\ble_ancs_c; components\ble\ble_services\ble_ans_c; components\ble\ble_services\ble_bas; components\ble\ble_services\ble_lbs; components\ble\ble_services\ble_bas_c; components\ble\ble_services\ble_cscs; components\ble\ble_services\ble_cts_c; components\ble\ble_services\ble_dfu; components\ble\ble_services\ble_dis; components\ble\ble_services\ble_gls; components\ble\ble_services\ble_hids; components\ble\ble_services\ble_hrs; components\ble\ble_services\ble_hrs_c; components\ble\ble_services\ble_hts; components\ble\ble_services\ble_ias; components\ble\ble_services\ble_ias_c; components\ble\ble_services\ble_lbs; components\ble\ble_services\ble_lbs_c; components\ble\ble_services\ble_lls; components\ble\ble_services\ble_nus; components\ble\ble_services\ble_nus_c; components\ble\ble_services\ble_rscs; components\ble\ble_services\ble_rscs_c; components\ble\ble_services\ble_tps; components\ble\common; components\ble\nrf_ble_gatt; components\ble\nrf_ble_qwr; components\ble\peer_manager; components\boards; components\libraries\atomic; components\libraries\atomic_fifo; components\libraries\atomic_flags; components\libraries\balloc; components\libraries\bootloader\ble_dfu; components\libraries\button; components\libraries\cli; components\libraries\crc16; components\libraries\crc32; components\libraries\crypto; components\libraries\csense; components\libraries\csense_drv; components\libraries\delay; components\libraries\ecc; components\libraries\experimental_section_vars; components\libraries\experimental_task_manager; components\libraries\fds; components\libraries\fstorage; components\libraries\gfx; components\libraries\gpiote; components\libraries\hardfault; components\libraries\hci; components\libraries\led_softblink; components\libraries\log; components\libraries\log\src; components\libraries\low_power_pwm; components\libraries\mem_manager; components\libraries\memobj; components\libraries\mpu; components\libraries\mutex; components\libraries\pwm; components\libraries\pwr_mgmt; components\libraries\queue; components\libraries\ringbuf; components\libraries\scheduler; components\libraries\sdcard; components\libraries\slip; components\libraries\sortlist; components\libraries\spi_mngr; components\libraries\stack_guard; components\libraries\strerror; components\libraries\svc; components\libraries\timer; components\libraries\twi_mngr; components\libraries\twi_sensor; components\libraries\usbd; components\libraries\usbd\class\audio; components\libraries\usbd\class\cdc; components\libraries\usbd\class\cdc\acm; components\libraries\usbd\class\hid; components\libraries\usbd\class\hid\generic; components\libraries\usbd\class\hid\kbd; components\libraries\usbd\class\hid\mouse; components\libraries\usbd\class\msc; components\libraries\util; components\softdevice\common; components\softdevice\s112\headers; components\softdevice\s112\headers\nrf52; components\toolchain\cmsis\include; external\fprintf; external\segger_rtt; external\utf_converter; integration\nrfx; integration\nrfx\legacy; modules\nrfx; modules\nrfx\drivers\include; modules\nrfx\hal; modules\nrfx\mdk; config; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; DEVELOP_IN_NRF52832; FLOAT_ABI_SOFT; NRF52810_XXAA; NRF52_PAN_74; NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3; NRF_SD_BLE_API_VERSION=7; S112; SOFTDEVICE_PRESENT
  AARM.AUserIncludes: \config; components; components\ble\ble_advertising; components\ble\ble_dtm; components\ble\ble_racp; components\ble\ble_services\ble_ancs_c; components\ble\ble_services\ble_ans_c; ..\..\..\components\ble\ble_services\ble_bas; ..\..\..\components\ble\ble_services\ble_bas_c; ..\..\..\components\ble\ble_services\ble_cscs; ..\..\..\components\ble\ble_services\ble_cts_c; ..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\components\ble\ble_services\ble_dis; ..\..\..\components\ble\ble_services\ble_gls; ..\..\..\components\ble\ble_services\ble_hids; ..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\components\ble\ble_services\ble_hrs_c; ..\..\..\components\ble\ble_services\ble_hts; ..\..\..\components\ble\ble_services\ble_ias; ..\..\..\components\ble\ble_services\ble_ias_c; ..\..\..\components\ble\ble_services\ble_lbs; ..\..\..\components\ble\ble_services\ble_lbs_c; components\ble\ble_services\ble_lls; ..\..\..\components\ble\ble_services\ble_nus; ..\..\..\components\ble\ble_services\ble_nus_c; ..\..\..\components\ble\ble_services\ble_rscs; ..\..\..\components\ble\ble_services\ble_rscs_c; ..\..\..\components\ble\ble_services\ble_tps; ..\..\..\components\ble\common; ..\..\..\components\ble\nrf_ble_gatt; ..\..\..\components\ble\nrf_ble_qwr; components\ble\peer_manager; components\boards; components\libraries\atomic; ..\..\..\components\libraries\atomic_fifo; ..\..\..\components\libraries\atomic_flags; ..\..\..\components\libraries\balloc; ..\..\..\components\libraries\bootloader\ble_dfu; ..\..\..\components\libraries\button; ..\..\..\components\libraries\cli; ..\..\..\components\libraries\crc16; ..\..\..\components\libraries\crc32; ..\..\..\components\libraries\crypto; ..\..\..\components\libraries\csense; ..\..\..\components\libraries\csense_drv; ..\..\..\components\libraries\delay; ..\..\..\components\libraries\ecc; ..\..\..\components\libraries\experimental_section_vars; ..\..\..\components\libraries\experimental_task_manager; ..\..\..\components\libraries\fds; ..\..\..\components\libraries\fstorage; ..\..\..\components\libraries\gfx; ..\..\..\components\libraries\gpiote; ..\..\..\components\libraries\hardfault; ..\..\..\components\libraries\hci; ..\..\..\components\libraries\led_softblink; ..\..\..\components\libraries\log; ..\..\..\components\libraries\log\src; ..\..\..\components\libraries\low_power_pwm; ..\..\..\components\libraries\mem_manager; ..\..\..\components\libraries\memobj; ..\..\..\components\libraries\mpu; ..\..\..\components\libraries\mutex; ..\..\..\components\libraries\pwm; ..\..\..\components\libraries\pwr_mgmt; ..\..\..\components\libraries\queue; ..\..\..\components\libraries\ringbuf; ..\..\..\components\libraries\scheduler; ..\..\..\components\libraries\sdcard; ..\..\..\components\libraries\slip; ..\..\..\components\libraries\sortlist; ..\..\..\components\libraries\spi_mngr; ..\..\..\components\libraries\stack_guard; ..\..\..\components\libraries\strerror; ..\..\..\components\libraries\svc; ..\..\..\components\libraries\timer; ..\..\..\components\libraries\twi_mngr; ..\..\..\components\libraries\twi_sensor; ..\..\..\components\libraries\usbd; ..\..\..\components\libraries\usbd\class\audio; ..\..\..\components\libraries\usbd\class\cdc; ..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\components\libraries\usbd\class\hid; ..\..\..\components\libraries\usbd\class\hid\generic; ..\..\..\components\libraries\usbd\class\hid\kbd; ..\..\..\components\libraries\usbd\class\hid\mouse; ..\..\..\components\libraries\usbd\class\msc; ..\..\..\components\libraries\util; components\softdevice\common; components\softdevice\s112\headers; components\softdevice\s112\headers\nrf52; ..\..\..\components\toolchain\cmsis\include; ..\..\..\external\fprintf; ..\..\..\external\segger_rtt; ..\..\..\external\utf_converter; ..\..\..\integration\nrfx; ..\..\..\integration\nrfx\legacy; ..\..\..\modules\nrfx; ..\..\..\modules\nrfx\drivers\include; ..\..\..\modules\nrfx\hal; modules\nrfx\mdk; config
  OBJCOPY.OOCOutputFile: wlible_b.hex
  postbuild: D:\nordic2\working_APP\working_APP\PREPARE_bzr_path.bat
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\nordic2\DeviceDownload (2)\wli_blebuzzer\ble_app_blinky_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ./: adc.c adv_h.c main.c
  group Board Definition
    components/boards/: boards.c
  group None
    modules/nrfx/mdk/: iar_startup_nrf52810.s system_nrf52810.c
  group nRF_BLE
    components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    components/ble/ble_services/ble_lbs/: ble_lbs.c
  group nRF_Drivers
    integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    modules/nrfx/hal/: nrf_nvmc.c
    components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    modules/nrfx/soc/: nrfx_atomic.c
    modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_pwm.c nrfx_saadc.c nrfx_timer.c nrfx_uart.c nrfx_uarte.c
    modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    components/libraries/button/: app_button.c
    components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    components/libraries/scheduler/: app_scheduler.c
    components/libraries/timer/: app_timer2.c drv_rtc.c
    components/libraries/hardfault/: hardfault_implementation.c
    components/libraries/atomic_fifo/: nrf_atfifo.c
    components/libraries/atomic_flags/: nrf_atflags.c
    components/libraries/atomic/: nrf_atomic.c
    components/libraries/balloc/: nrf_balloc.c
    external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    components/libraries/memobj/: nrf_memobj.c
    components/libraries/ringbuf/: nrf_ringbuf.c
    components/libraries/experimental_section_vars/: nrf_section_iter.c
    components/libraries/sortlist/: nrf_sortlist.c
    components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_SoftDevice
    components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group UTF8/UTF16 converter
    external/utf_converter/: utf.c
